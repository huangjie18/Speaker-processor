# Keil uVision project Processor.uvprojx, settings and files
target Processor (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Processor +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD;..\STemWin\Config;..\STemWin\inc;..\MALLOC;..\HARDWARE\TIMER;..\STemWin\Demo;..\HARDWARE\Test
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_tim.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/Test/: test.c example.c
  group STemWin_Config
    ../STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c
    ../STemWin/OS/: GUI_X.c
  group STemWin_LIB
    ../STemWin/Lib/: STemWin526_CM3_Keil.lib
  group malloc
    ../MALLOC/: malloc.c
